LED_FILE_orange-pi-lite = "/sys/devices/platform/leds/leds/orangepi\:red\:status/brightness"
LED_FILE_orange-pi-zero = "/sys/devices/platform/leds/leds/orangepi\:red\:status/brightness"

LED_FILE_nanopi-neo-air = "/sys/class/leds/nanopi\:blue\:status/brightness"

LED_FILE_olimex-a20-negotica = "/sys/class/leds/a20-olimex-som\:green\:usr/brightness"
